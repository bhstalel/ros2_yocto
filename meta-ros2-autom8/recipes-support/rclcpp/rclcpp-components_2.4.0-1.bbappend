ATOMICL = "-latomic"

TARGET_LDFLAGS_pn-rclcpp-components_append = " ${ATOMICL}"